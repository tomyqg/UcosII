# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\User; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\User\uCOS-II\ucCos_App\; ..\User\uCOS-II\uC-CPU; ..\User\uCOS-II\uC-LIB; ..\User\uCOS-II\uCOS-II; ..\User\uCOS-II\uCOS-II\Source; ..\User\uCOS-II\uCOS-VIEW; ..\User\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\IAR; ..\User\uCOS-II\uC-CPU\ARM-Cortex-M3\iar; ..\User\AppTask; ..\User\BSP\GENERAL; ..\User\Hardware; ..\User\Hardware\Gui
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group App
    AppTask/: app.c main.c system_stm32f10x.c
  group Hardware
    Hardware/: adc.c DmaDac.c oled.c tim.c usart.c
  group Hardware/Gui
    Hardware/Gui/: ConvertColor.c FONT24_32.C font5_7.c FONT8_8.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c
    Hardware/: LCD12864.c
  group Lib/BSP
    BSP/GENERAL/: bsp.c bsp.h bsp_int.c bsp_periph.c bsp_vector.c
  group Lib/CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Lib/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-II
    uCOS-II/uC-CPU/ARM-Cortex-M3/iar/: cpu_a.asm cpu_c.c
    uCOS-II/uC-LIB/: lib_mem.c lib_str.c
    uCOS-II/uC-LIB/Ports/iar/: lib_mem_a.asm
    uCOS-II/ucCos_App/: OS_AppHooks.c
    uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    uCOS-II/uCOS-VIEW/Source/: os_view.c
